<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$/swol_test.ewp</path>
  </project>
  <project>
    <path>$SIMPLELINK_CC2640R2_SDK_INSTALL_DIR$/kernel/tirtos/builds/CC2640R2_LAUNCHXL/release/iar/tirtos_builds_CC2640R2_LAUNCHXL_release.ewp</path>
  </project>
  <batchBuild/>
</workspace>
